# Keil uVision project AN2295_Kinetis.uvproj, settings and files
target Kinetis K 120MHz (ARM-ADS)
  device: MK70FN1M0xxx15 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: AN2295_KinetisK_120MHz +hex
  c flags: Optim=4 OneElfS=1
  c define: KINETIS_K=0x12, __GNUC__
  c include: ..\CommonSource;..\CommonSource\bootloader;..\CommonSource\crc;..\CommonSource\flash;..\CommonSource\rs232;..\CommonSource\wdg;..\CommonSource\headers
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: AN2295_Kinetis.scf
  group bootloader
    ../CommonSource/bootloader/: bootloader.c bootloader.h kinetis_params.h bootloader_asm.s
    ../CommonSource/: main.h
    ./: linker_symbols.s
  group crc
    ../CommonSource/crc/: crc.c crc.h
  group rs232
    ../CommonSource/rs232/: rs232.c rs232.h
  group wdg
    ../CommonSource/wdg/: wdg.h
  group flash
    ../CommonSource/flash/: flash_kinetis.c flash_kinetis.h flash_kinetisRamFunc.c
  group config
    ../CommonSource/: AN2295_FRDM_KL25Z_cfg.h AN2295_TWR_K60_cfg.h AN2295_TWR_KL25_cfg.h bootloader_cfg.h AN2295_TWR_K20D50_cfg.h AN2295_TWR_K20D72_cfg.h AN2295_TWR_K60D100_cfg.h AN2295_TWR_K70120_cfg.h
  group headers
    ../CommonSource/headers/: MK10D5.h MK10DZ10.h MK10F12.h MK20D5.h MK20DZ10.h MK20F12.h MK30DZ10.h MK40DZ10.h MK50DZ10.h MK51DZ10.h MK52DZ10.h MK53DZ10.h MK60DZ10.h MK60F12.h MK60F15.h MK61F12.h MK61F15.h MK70F12.h MK70F15.h MKL05Z32LF4.h MKL25Z4.h MKL25Z128LK4.h MKM34Z128LL5.h MK60D10.h
target Kinetis K 100MHz (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: AN2295_KinetisK_100MHz +hex
  c flags: Optim=4 OneElfS=1
  c define: KINETIS_K=0x10, __GNUC__
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: AN2295_Kinetis.scf
target Kinetis K 72MHz (ARM-ADS)
  device: MK20DX64xxx7 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0x0FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: AN2295_KinetisK_72MHz +hex
  c flags: Optim=4 OneElfS=1
  c define: KINETIS_K=0x07, __GNUC__
  c include: as above
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: AN2295_Kinetis.scf
target Kinetis K 50MHz (ARM-ADS)
  device: MK20DN32xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20000FFF) IROM(0x0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: AN2295_KinetisK_50MHz +hex
  c flags: Optim=4 OneElfS=1
  c define: KINETIS_K=0x05, __GNUC__
  c include: as above
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x1000
  scatter file: AN2295_Kinetis.scf
target Kinetis L 48MHz (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: AN2295_KinetisL +hex
  c flags: Optim=4 OneElfS=1
  c define: KINETIS_L __GNUC__
  c include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1fffff00 size 0x100
  memory RVCT10: RAM 0x20000000 size 0x200
  scatter file: AN2295_Kinetis.scf
