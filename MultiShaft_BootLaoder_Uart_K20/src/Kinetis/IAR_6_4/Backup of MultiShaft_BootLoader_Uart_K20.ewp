# IAR project Backup of MultiShaft_BootLoader_Uart_K20.ewp, settings and files
configuration Kinetis K Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX256xxx7 Freescale MK20DX256xxx7
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: KINETIS_K=0x07
  ICCARM.CCIncludePath2: ..\CommonSource\headers; ..\CommonSource\wdg; ..\CommonSource\flash; ..\CommonSource\crc; ..\CommonSource\rs232; ..\CommonSource\bootloader; ..\CommonSource\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AN2295_Kinetis.srec
  ILINK.IlinkOutputFile: AN2295_Kinetis.out
  ILINK.IlinkIcfFile: IAR_Linker_cfg\AN2295_LinkerFile.icf
  ILINK.IlinkProgramEntryLabel: __main
configuration Kinetis L Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL25Z32xxx4 Freescale MKL25Z32xxx4
  General.CoreVariant: 35
  ICCARM.CCDefines: KINETIS_L
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: AN2295_KinetisL.out
configuration Kinetis L Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL25Z32xxx4 Freescale MKL25Z32xxx4
  General.CoreVariant: 35
  ICCARM.CCDefines: KINETIS_L
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: AN2295_KinetisL.out
configuration Kinetis K 50MHz Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK10DN32xxx5 Freescale MK10DN32xxx5
  ICCARM.CCDefines: KINETIS_K=5
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
configuration Kinetis K 72MHz Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK10DX64xxx7 Freescale MK10DX64xxx7
  ICCARM.CCDefines: KINETIS_K=7
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
configuration Kinetis K 120MHz Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK10FN1M0xxx12 Freescale MK10FN1M0xxx12
  General.FPU2: 4
  ICCARM.CCDefines: KINETIS_K=0x12
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
configuration Kinetis K 100MHz Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  ICCARM.CCDefines: KINETIS_K=0x10
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
configuration Kinetis M Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKM34Z128xxx5 Freescale MKM34Z128xxx5
  General.CoreVariant: 35
  ICCARM.CCDefines: KINETIS_M
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: AN2295_KinetisL.out
configuration Kinetis K-1M 100MHz Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: KINETIS_K=0x10
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
configuration Kinetis K-1M 100MHz Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  ICCARM.CCDefines: KINETIS_K=0x10
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
configuration Kinetis M Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKM34Z128xxx5 Freescale MKM34Z128xxx5
  General.CoreVariant: 35
  ICCARM.CCDefines: KINETIS_M
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: AN2295_KinetisL.out
configuration Kinetis K 100MHz Flex Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: KINETIS_K=0x10
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
configuration Kinetis K 72MHz Flex Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: KINETIS_K=7
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group (top)
    IAR_Linker_cfg/: AN2295_LinkerFile.icf
    ../CommonSource/: main.h
  group BootCfg
    ../CommonSource/: AN2295_FRDM_KL25Z_cfg.h AN2295_TWR_K20_1M_cfg.h AN2295_TWR_K20D50_cfg.h AN2295_TWR_K20D72_cfg.h AN2295_TWR_K20X256_cfg.h AN2295_TWR_K60_cfg.h AN2295_TWR_K60D100_cfg.h AN2295_TWR_K70120_cfg.h AN2295_TWR_KL25_cfg.h AN2295_TWR_KM34_cfg.h AN2295_VAL_KM34_cfg.h bootloader_cfg.h
  group Bootloader
    ../CommonSource/bootloader/: bootloader.c bootloader.h kinetis_params.h
  group CRC
    ../CommonSource/crc/: crc.c crc.h
  group FLASH
    ../CommonSource/flash/: flash_kinetis.c flash_kinetis.h flash_kinetisRamFunc.c
  group headers
    ../CommonSource/headers/: MK10D5.h MK10DZ10.h MK10F12.h MK20D5.h MK20DZ10.h MK20F12.h MK22F10.h MK30DZ10.h MK40DZ10.h MK50DZ10.h MK51DZ10.h MK52DZ10.h MK53DZ10.h MK60D10.h MK60DZ10.h MK60F12.h MK60F15.h MK61F12.h MK61F15.h MK70F12.h MK70F15.h MKL05Z32LF4.h MKL25Z128LK4.h MKL25Z4.h MKM34Z5.h
  group RS232
    ../CommonSource/rs232/: rs232.c rs232.h
  group WDG
    ../CommonSource/wdg/: wdg.h
